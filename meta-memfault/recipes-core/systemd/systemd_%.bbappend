# Disable systemd-pstore
EXTRA_OEMESON_append = " -Dpstore=false"
