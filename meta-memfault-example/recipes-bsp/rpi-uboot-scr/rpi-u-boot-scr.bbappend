FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

COMPATIBLE = "raspberrypi2 raspberrypi3 raspberrypi4"
